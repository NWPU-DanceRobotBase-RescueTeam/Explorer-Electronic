# Keil uVision project moter.uvprojx, settings and files
target moter (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\CAN;..\HARDWARE\queue;..\HARDWARE\FSM;..\HARDWARE\Motor_Control;..\HARDWARE\TIM;..\HARDWARE\debug;..\HARDWARE\AS69-T20;..\HARDWARE\STMFLASH;..\HARDWARE\Sensor;..\HARDWARE\ADC;..\HARDWARE\IWDG;..\HARDWARE\Paint\Config;..\HARDWARE\Paint\EPD;..\HARDWARE\Paint\Fonts;..\HARDWARE\Paint\GUI;..\HARDWARE\Paint\SPI;..\HARDWARE\Paint\TEST
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Motor_Control/: Motor_Control.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/debug/: debug.c
    ../HARDWARE/FSM/: FSM.c
    ../HARDWARE/Sensor/: sensor.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/Paint/SPI/: spi.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/Paint/Config/: DEV_Config.c
    ../HARDWARE/Paint/EPD/: EPD_4in2bc.c
    ../HARDWARE/Paint/TEST/: EPD_4in2bc_test.c
    ../HARDWARE/Paint/Fonts/: font12CN.c font24.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_iwdg.c
  group README
    ../: readme.txt
