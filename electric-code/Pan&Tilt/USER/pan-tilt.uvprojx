# Keil uVision project pan-tilt.uvprojx, settings and files
target pan-tilt (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\AX12;..\HARDWARE\CAN;..\HARDWARE\queue;..\HARDWARE\Angle;..\HARDWARE\TIM;..\HARDWARE\DMA;..\HARDWARE\IMU
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/AX12/: AX12.c
    ../HARDWARE/CAN/: CAN.c
    ../HARDWARE/queue/: queue.c
    ../HARDWARE/Angle/: Angle.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/IMU/: IMU.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_spi.c
  group README
    ../: readme.txt
