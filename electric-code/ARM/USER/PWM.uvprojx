# Keil uVision project PWM.uvprojx, settings and files
target PWM (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\PWM;..\FWLIB\inc;..\HARDWARE\ARM;..\HARDWARE\CAN;..\HARDWARE\TIM;..\HARDWARE\Motor_Control;..\HARDWARE\ADC;..\HARDWARE\POT;..\HARDWARE\DEBUG;..\HARDWARE\FSM;..\HARDWARE\EXTI;..\HARDWARE\IWDG;..\HARDWARE\GIM8008
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/ARM/: arm.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/Motor_Control/: Motor_Control.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/POT/: pot.c
    ../HARDWARE/DEBUG/: debug.c
    ../HARDWARE/FSM/: FSM.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/GIM8008/: GIM8008.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_iwdg.c
  group README
    ../: readme.txt
